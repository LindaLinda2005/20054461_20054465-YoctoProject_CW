FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://add-autoboot-keyed.patch"
